options:
  parameters:
    author: Felix Wunsch
    category: DRM
    description: MLC 16QAM
    generate_options: hb
    id: drm_mlc_16qam_bc
    output_language: python
    title: MLC 16QAM
  states: {}

blocks:
- name: M_total
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: bits_per_symbol
  id: parameter
  parameters:
    label: Bits per Symbol
    type: intx
    value: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_bot
  id: blocks_unpack_k_bits_bb
  parameters:
    k: denom_mother_code_rate
  states: {}
- name: blocks_unpack_k_bits_bb_top
  id: blocks_unpack_k_bits_bb
  parameters:
    k: denom_mother_code_rate
  states: {}
- name: denom_mother_code_rate
  id: parameter
  parameters:
    label: Denominator of the Mother Code Rate
    type: intx
    value: '1'
  states: {}
- name: drm_add_tailbits_bb_bot
  id: drm_add_tailbits_bb
  parameters:
    n_tailbits: n_tailbits
    vlen_in: part_len_bot
  states: {}
- name: drm_add_tailbits_bb_top
  id: drm_add_tailbits_bb
  parameters:
    n_tailbits: n_tailbits
    vlen_in: part_len_top
  states: {}
- name: drm_interleaver_bb_bot
  id: drm_interleaver_bb
  parameters:
    interl_seq: interl_seq_1_2
  states: {}
- name: drm_interleaver_bb_top
  id: drm_interleaver_bb
  parameters:
    interl_seq: interl_seq_0_2
  states: {}
- name: drm_partitioning_16_bb_0
  id: drm_partitioning_16_bb
  parameters:
    vlen1: part_len_top
    vlen2: part_len_bot
    vlen_in: vlen_in
    vlen_out: M_total
  states: {}
- name: drm_punct_bb_bot
  id: drm_punct_bb
  parameters:
    num_tailbits: n_tailbits * denom_mother_code_rate
    punct_pat_1: pp_1
    punct_pat_2: pp_1_tail
    vlen_in: (part_len_bot + n_tailbits) * denom_mother_code_rate
    vlen_out: vlen_out * 2
  states: {}
- name: drm_punct_bb_top
  id: drm_punct_bb
  parameters:
    num_tailbits: n_tailbits * denom_mother_code_rate
    punct_pat_1: pp_0
    punct_pat_2: pp_0_tail
    vlen_in: (part_len_top + n_tailbits) * denom_mother_code_rate
    vlen_out: vlen_out * 2
  states: {}
- name: drm_qam_map_bc_0
  id: drm_qam_map_bc
  parameters:
    bits_per_symbol: bits_per_symbol
    map_table: map_tab
    n_inputs: '2'
    vlen_out: vlen_out
  states: {}
- name: gen_poly
  id: parameter
  parameters:
    label: Generator Polynomial
    value: '0'
  states: {}
- name: interl_seq_0_2
  id: parameter
  parameters:
    label: Interleaving Sequence 0
    value: (0,1)
  states: {}
- name: interl_seq_1_2
  id: parameter
  parameters:
    label: Interleaving Sequence 1
    value: (0,1)
  states: {}
- name: map_tab
  id: parameter
  parameters:
    label: Mapping Table
    value: '0'
  states: {}
- name: n_tailbits
  id: parameter
  parameters:
    label: Number of Tailbits
    type: intx
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: part_len_bot
  id: parameter
  parameters:
    label: M_total[1]
    value: '3'
  states: {}
- name: part_len_top
  id: parameter
  parameters:
    label: M_total[0]
    value: '3'
  states: {}
- name: pp_0
  id: parameter
  parameters:
    label: Puncturing Pattern 0
    value: '0'
  states: {}
- name: pp_0_tail
  id: parameter
  parameters:
    label: Tail Bit Puncturing Pattern 0
    value: '0'
  states: {}
- name: pp_1
  id: parameter
  parameters:
    label: Puncturing Pattern 1
    value: '0'
  states: {}
- name: pp_1_tail
  id: parameter
  parameters:
    label: Tail Bit Puncturing Pattern 1
    value: '0'
  states: {}
- name: trellis_encoder_xx_bot
  id: trellis_encoder_xx
  parameters:
    fsm_args: 1, denom_mother_code_rate, gen_poly
    init_state: '0'
    type: bb
  states: {}
- name: trellis_encoder_xx_top
  id: trellis_encoder_xx
  parameters:
    fsm_args: 1, denom_mother_code_rate, gen_poly
    init_state: '0'
    type: bb
  states: {}
- name: vlen_in
  id: parameter
  parameters:
    label: Input Vector Length
    type: intx
    value: '1'
  states: {}
- name: vlen_out
  id: parameter
  parameters:
    label: Output Vector Length
    type: intx
    value: '1'
  states: {}

connections:
- [blocks_unpack_k_bits_bb_bot, '0', drm_punct_bb_bot, '0']
- [blocks_unpack_k_bits_bb_top, '0', drm_punct_bb_top, '0']
- [drm_add_tailbits_bb_bot, '0', trellis_encoder_xx_bot, '0']
- [drm_add_tailbits_bb_top, '0', trellis_encoder_xx_top, '0']
- [drm_interleaver_bb_bot, '0', drm_qam_map_bc_0, '1']
- [drm_interleaver_bb_top, '0', drm_qam_map_bc_0, '0']
- [drm_partitioning_16_bb_0, '0', drm_add_tailbits_bb_top, '0']
- [drm_partitioning_16_bb_0, '1', drm_add_tailbits_bb_bot, '0']
- [drm_punct_bb_bot, '0', drm_interleaver_bb_bot, '0']
- [drm_punct_bb_top, '0', drm_interleaver_bb_top, '0']
- [drm_qam_map_bc_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', drm_partitioning_16_bb_0, '0']
- [trellis_encoder_xx_bot, '0', blocks_unpack_k_bits_bb_bot, '0']
- [trellis_encoder_xx_top, '0', blocks_unpack_k_bits_bb_top, '0']

metadata:
  file_format: 1
