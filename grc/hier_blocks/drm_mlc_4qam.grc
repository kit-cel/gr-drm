options:
  parameters:
    author: Felix Wunsch
    category: DRM
    description: MLC 4QAM
    generate_options: hb
    id: drm_mlc_4qam_bc
    output_language: python
    title: MLC 4QAM
  states: {}

blocks:
- name: add_tailbits_bb_0
  id: drm_add_tailbits_bb
  parameters:
    n_tailbits: n_tailbits
    vlen_in: vlen_in
  states: {}
- name: bits_per_symbol
  id: parameter
  parameters:
    label: Bits per Symbol
    type: intx
    value: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: denom_mother_code_rate
  states: {}
- name: denom_mother_code_rate
  id: parameter
  parameters:
    label: Denominator Mother Code Rate
    type: intx
    value: '1'
  states: {}
- name: drm_interleaver_bb_0
  id: drm_interleaver_bb
  parameters:
    interl_seq: (interl_seq)
  states: {}
- name: drm_punct_bb_0
  id: drm_punct_bb
  parameters:
    num_tailbits: n_tailbits * denom_mother_code_rate
    punct_pat_1: pp
    punct_pat_2: pp_tail
    vlen_in: (vlen_in + n_tailbits) * denom_mother_code_rate
    vlen_out: vlen_out * 2
  states: {}
- name: drm_qam_map_bc_0
  id: drm_qam_map_bc
  parameters:
    bits_per_symbol: bits_per_symbol
    map_table: map_tab
    n_inputs: '1'
    vlen_out: vlen_out
  states: {}
- name: gen_poly
  id: parameter
  parameters:
    label: Generator Polynomial
    value: '0'
  states: {}
- name: interl_seq
  id: parameter
  parameters:
    label: Interleaving Sequence
    value: (0,1)
  states: {}
- name: map_tab
  id: parameter
  parameters:
    label: Mapping Table
    value: '0'
  states: {}
- name: n_tailbits
  id: parameter
  parameters:
    label: Number of Tail Bits
    type: intx
    value: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: values given to parameters are only placeholders and are overwritten by the actual configuration in the flow graph
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pp
  id: parameter
  parameters:
    label: Puncturing Pattern
    value: '0'
  states: {}
- name: pp_tail
  id: parameter
  parameters:
    label: Puncturing Pattern Tail  Bits
    value: '0'
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: 1, denom_mother_code_rate, gen_poly
    init_state: '0'
    type: bb
  states: {}
- name: vlen_in
  id: parameter
  parameters:
    label: Input Vector Length
    type: intx
    value: '1'
  states: {}
- name: vlen_out
  id: parameter
  parameters:
    label: Output Vector Length
    type: intx
    value: '1'
  states: {}

connections:
- [add_tailbits_bb_0, '0', trellis_encoder_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', drm_punct_bb_0, '0']
- [drm_interleaver_bb_0, '0', drm_qam_map_bc_0, '0']
- [drm_punct_bb_0, '0', drm_interleaver_bb_0, '0']
- [drm_qam_map_bc_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', add_tailbits_bb_0, '0']
- [trellis_encoder_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
