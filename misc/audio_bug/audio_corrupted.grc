<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>audio_sample_rate</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SO</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msc_prot_level_2</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RM</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>240</value></param>
<param><key>interp</key><value>441</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0/32768</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>drm_audio_decoder_vbs</key>
<param><key>id</key><value>drm_audio_decoder_vbs_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_2</value></param>
<param><key>file</key><value>pcm_in_s</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_3</value></param>
<param><key>file</key><value>pcm_in_f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_0</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_4</value></param>
<param><key>file</key><value>pcm_res_f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>pcm_dec_s</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1</value></param>
<param><key>file</key><value>pcm_dec_f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_float_to_short</key>
<param><key>id</key><value>gr_float_to_short_0</value></param>
</block>
<block>
<key>drm_audio_encoder_svb</key>
<param><key>id</key><value>drm_audio_encoder_svb_0</value></param>
<param><key>tp</key><value>tp</value></param>
<param><key>len_out</key><value>tp.msc().L_MUX()</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>32768</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>init_0</value></param>
<param><key>import</key><value>import drm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tp</value></param>
<param><key>value</key><value>drm.transm_params(RM, SO, False, 0, False, 1, 0, msc_prot_level_2, 1, 0, False, audio_sample_rate, "", "")</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>audio_corrupted</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>gr_wavfile_source</key>
<param><key>id</key><value>gr_wavfile_source_0</value></param>
<param><key>file</key><value></value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>nchan</key><value>1</value></param>
</block>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_file_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_audio_decoder_vbs_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_wavfile_source_0</source_block_id><sink_block_id>gr_file_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_short_0</source_block_id><sink_block_id>gr_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_wavfile_source_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_0</source_block_id><sink_block_id>gr_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>drm_audio_encoder_svb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_audio_decoder_vbs_0</source_block_id><sink_block_id>gr_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_audio_encoder_svb_0</source_block_id><sink_block_id>drm_audio_decoder_vbs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
