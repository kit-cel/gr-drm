<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>noise_ampl</value></param>
<param><key>label</key><value>noise_ampl</value></param>
<param><key>value</key><value>4.4</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>15</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>input_power</value></param>
<param><key>note</key><value>mean abs of input data is 14. SNR of 10 dB should correspond to an noise_ampl of 4.4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import drmrx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx</value></param>
<param><key>value</key><value>drmrx.drmrx_conf()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>skip0</value></param>
<param><key>label</key><value>skip0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>(0,0,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>skip1</value></param>
<param><key>label</key><value>skip1</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>(0,1,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>skip2</value></param>
<param><key>label</key><value>skip2</value></param>
<param><key>value</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>(1,0,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_influence</value></param>
<param><key>label</key><value>channel_influence</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>f_off</value></param>
<param><key>label</key><value>f_off</value></param>
<param><key>value</key><value>305</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>channel_sim</key>
<param><key>id</key><value>channel_sim_0</value></param>
<param><key>skip0</key><value>skip0</value></param>
<param><key>skip1</key><value>skip1</value></param>
<param><key>skip2</key><value>skip2</value></param>
<param><key>noise_ampl</key><value>noise_ampl</value></param>
<param><key>f_off</key><value>f_off</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>filename</key><value>"/home/felixwunsch/src/gr-drm/gr-drmrx/test_data/baseband_rmbso3.dat"</value></param>
<param><key>m2</key><value>(0.2-0.1j)*channel_influence</value></param>
<param><key>m1</key><value>(0.4+0.2j)*channel_influence</value></param>
<param><key>m0</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>after sync</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>(2,1,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>before sync</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>(2,0,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>drmrx_cp_sync_py</key>
<param><key>id</key><value>drmrx_cp_sync_py_0</value></param>
<param><key>rx</key><value>rx</value></param>
</block>
<block>
<key>drmrx_freq_sync_py</key>
<param><key>id</key><value>drmrx_freq_sync_py_0</value></param>
<param><key>rx</key><value>rx</value></param>
</block>
<connection><source_block_id>channel_sim_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_sim_0</source_block_id><sink_block_id>drmrx_freq_sync_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drmrx_cp_sync_py_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drmrx_freq_sync_py_0</source_block_id><sink_block_id>drmrx_cp_sync_py_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
