<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>RM</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tp</value></param>
<param><key>value</key><value>drm.transm_params(RM, SO, False, 0, False, 1, 0, msc_prot_level_2, 1, 0, long_interl, audio_sample_rate, station_label, text_message)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msc_prot_level_2</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_sample_rate</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>long_interl</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>station_label</value></param>
<param><key>value</key><value>"GNU Radio on DRM"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>text_message</value></param>
<param><key>value</key><value>"\x48\x65\x6c\x6c\x6f\x21\x20\x2f\x20\x48\x61\x6c\x6c\x6f\x21\x20\x2f\x20\xd0\x9f\xd1\x80\xd0\xb8\xd0\xb2\xd0\xb5\xd1\x82\x21\x20\x2f\x20\x21\xd8\xb3\xd9\x84\xd8\xa7\xd9\x85"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SO</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>drm_generate_fac_vb</key>
<param><key>id</key><value>drm_generate_fac_vb_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_0</value></param>
<param><key>block_len</key><value>tp.fac().L()</value></param>
</block>
<block>
<key>drm_generate_sdc_vb</key>
<param><key>id</key><value>drm_generate_sdc_vb_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_1</value></param>
<param><key>block_len</key><value>tp.sdc().L()</value></param>
</block>
<block>
<key>drm_mlc_4qam_vbvc</key>
<param><key>id</key><value>drm_mlc_4qam_vbvc_0</value></param>
<param><key>vlen_in</key><value>tp.sdc().L()</value></param>
<param><key>vlen_out</key><value>tp.sdc().N()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>map_tab</key><value>tp.cfg().ptables().d_QAM4</value></param>
<param><key>interl_seq</key><value>tp.sdc().bit_interl_seq_0_2()</value></param>
<param><key>bits_per_symbol</key><value>tp.sdc().mod_order()</value></param>
<param><key>pp</key><value>tp.sdc().punct_pat_0()</value></param>
<param><key>pp_tail</key><value>tp.sdc().punct_pat_tail_0()</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0</value></param>
<param><key>block_len</key><value>tp.msc().L_MUX()</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Before generating the flow graph, define the path to a 24 kHz wav-file and change the parameters of the UHD sink. Do not forget to set the correct audio_sample_rate.</value></param>
</block>
<block>
<key>drm_mlc_16qam_vbvc</key>
<param><key>id</key><value>drm_mlc_16qam_vbvc_0</value></param>
<param><key>vlen_in</key><value>tp.msc().L_MUX()</value></param>
<param><key>vlen_out</key><value>tp.msc().N_MUX()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
<param><key>bits_per_symbol</key><value>tp.msc().mod_order()</value></param>
<param><key>map_tab</key><value>tp.cfg().ptables().d_QAM16</value></param>
<param><key>pp_0</key><value>tp.msc().punct_pat_0_2()</value></param>
<param><key>interl_seq_0_2</key><value>tp.msc().bit_interl_seq_0_2()</value></param>
<param><key>interl_seq_1_2</key><value>tp.msc().bit_interl_seq_1_2()</value></param>
<param><key>pp_1_tail</key><value>tp.msc().punct_pat_tail_1_2()</value></param>
<param><key>pp_1</key><value>tp.msc().punct_pat_1_2()</value></param>
<param><key>pp_0_tail</key><value>tp.msc().punct_pat_tail_0_2()</value></param>
<param><key>M_total</key><value>tp.msc().M_total()</value></param>
<param><key>part_len_top</key><value>tp.msc().M_total()[0]</value></param>
<param><key>part_len_bot</key><value>tp.msc().M_total()[1]</value></param>
</block>
<block>
<key>drm_interleaver_vcvc</key>
<param><key>id</key><value>drm_interleaver_vcvc_0</value></param>
<param><key>interl_seq</key><value>tp.msc().cell_interl_seq()</value></param>
<param><key>long_interl</key><value>long_interl</value></param>
<param><key>depth</key><value>drm.INTL_DEPTH_DRM</value></param>
</block>
<block>
<key>cell_mapping_vcvc</key>
<param><key>id</key><value>cell_mapping_vcvc_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>post_cell_mapping.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>drm_mlc_4qam_vbvc</key>
<param><key>id</key><value>drm_mlc_4qam_vbvc_0_0</value></param>
<param><key>vlen_in</key><value>tp.fac().L()</value></param>
<param><key>vlen_out</key><value>tp.fac().N()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>map_tab</key><value>tp.cfg().ptables().d_QAM4</value></param>
<param><key>interl_seq</key><value>tp.fac().bit_interl_seq_0_2()</value></param>
<param><key>bits_per_symbol</key><value>tp.fac().mod_order()</value></param>
<param><key>pp</key><value>tp.fac().punct_pat_0()</value></param>
<param><key>pp_tail</key><value>tp.fac().punct_pat_0()</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>post_mlc4.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>65</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp.ofdm().M_TF()</value></param>
<param><key>vlen</key><value>tp.msc().N_MUX()</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp.ofdm().M_TF()</value></param>
<param><key>vlen</key><value>tp.fac().N()</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>7e-3</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_1</value></param>
<param><key>input_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>cp_len</key><value>tp.ofdm().nfft()/4</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>7000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>file</key><value>drm_out.wav</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate * 250 / 48</value></param>
<param><key>center_freq0</key><value>5e6</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>TXB</value></param>
</block>
<block>
<key>drm_audio_encoder_svb</key>
<param><key>id</key><value>drm_audio_encoder_svb_0</value></param>
<param><key>tp</key><value>tp</value></param>
<param><key>len_out</key><value>tp.msc().L_MUX()</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>240</value></param>
<param><key>decim</key><value>441</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>drm_transmitter_16_4</value></param>
<param><key>title</key><value>DRM Transmitter 1</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>16/4/4 QAM, EEP</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>run</key><value>False</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>32768</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/felixwunsch/Musik/short24.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>drm_m3ufile_source_f</key>
<param><key>id</key><value>drm_m3ufile_source_f_0</value></param>
<param><key>filename</key><value></value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<connection><source_block_id>drm_scrambler_vbvb_0_0</source_block_id><sink_block_id>drm_mlc_4qam_vbvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_fac_vb_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_sdc_vb_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0_1</source_block_id><sink_block_id>drm_mlc_4qam_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0</source_block_id><sink_block_id>drm_mlc_16qam_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_audio_encoder_svb_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_16qam_vbvc_0</source_block_id><sink_block_id>drm_interleaver_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_4qam_vbvc_0</source_block_id><sink_block_id>cell_mapping_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>cell_mapping_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vcvc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>cell_mapping_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>drm_mlc_4qam_vbvc_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_vcvc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_4qam_vbvc_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>drm_audio_encoder_svb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>drm_audio_encoder_svb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_vcvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_m3ufile_source_f_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
