options:
  parameters:
    author: Felix Wunsch
    category: Custom
    description: RM B, SO 3, 16/4/4 QAM, short interleaving, EEP
    generate_options: no_gui
    id: drm_plus_transmitter
    output_language: python
    realtime_scheduling: '1'
    run: 'False'
    run_options: run
    title: DRM+ Transmitter
  states: {}

blocks:
- name: RM
  id: variable
  parameters:
    value: '4'
  states: {}
- name: SO
  id: variable
  parameters:
    value: '0'
  states: {}
- name: audio_sample_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: msc_prot_level_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 96e3
  states: {}
- name: station_label
  id: variable
  parameters:
    value: '"GNU Radio on DRM"'
  states: {}
- name: text_message
  id: variable
  parameters:
    value: '"\x48\x65\x6c\x6c\x6f\x21\x20\x2f\x20\x48\x61\x6c\x6c\x6f\x21\x20\x2f\x20\xd0\x9f\xd1\x80\xd0\xb8\xd0\xb2\xd0\xb5\xd1\x82\x21\x20\x2f\x20\x21\xd8\xb3\xd9\x84\xd8\xa7\xd9\x85"'
  states: {}
- name: tp
  id: variable
  parameters:
    value: drm.transm_params(RM, SO, False, 0, 0, 0, msc_prot_level_2, 1, 0, True, audio_sample_rate, station_label, text_message)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '70000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '7e-3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: drm_out.wav
    samp_rate: int(samp_rate*2)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {state: disabled}
- name: cell_mapping_cc_0
  id: cell_mapping_cc
  parameters:
    tp: tp
  states: {}
- name: digital_ofdm_cyclic_prefixer_1
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: tp.ofdm().nfft()//4
    input_size: tp.ofdm().nfft()
    tagname: ''
  states: {}
- name: drm_audio_encoder_sb_0
  id: drm_audio_encoder_sb
  parameters:
    len_out: tp.msc().L_MUX()
    tp: tp
  states: {}
- name: drm_generate_fac_b_0
  id: drm_generate_fac_b
  parameters:
    tp: tp
  states: {}
- name: drm_generate_sdc_b_0
  id: drm_generate_sdc_b
  parameters:
    tp: tp
  states: {}
- name: drm_interleaver_cc_0
  id: drm_interleaver_cc
  parameters:
    depth: drm.INTL_DEPTH_DRMPLUS
    interl_seq: tp.msc().cell_interl_seq()
    long_interl: 'True'
  states: {}
- name: drm_scrambler_bb_0
  id: drm_scrambler_bb
  parameters:
    block_len: tp.msc().L_MUX()
  states: {}
- name: drm_scrambler_bb_0_0
  id: drm_scrambler_bb
  parameters:
    block_len: tp.fac().L()
  states: {}
- name: drm_scrambler_bb_0_1
  id: drm_scrambler_bb
  parameters:
    block_len: tp.sdc().L()
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: tp.ofdm().nfft()
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: mlc_bc_0_0
  id: mlc_bc
  parameters:
    channel_type: '"FAC"'
    tp: tp
  states: {}
- name: mlc_bc_0_0_0
  id: mlc_bc
  parameters:
    channel_type: '"SDC"'
    tp: tp
  states: {}
- name: mlc_bc_0_0_1
  id: mlc_bc
  parameters:
    channel_type: '"MSC"'
    tp: tp
  states: {}
- name: note_0
  id: note
  parameters:
    note: Before generating the flow graph, define the path to a 24 kHz wav-file and change the parameters of the UHD sink. Do not forget to set the correct audio_sample_rate.
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '92'
    interp: '250'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '240'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TXB
    center_freq0: 5e6
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate * 250 / 48
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', drm_audio_encoder_sb_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [cell_mapping_cc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_1, '0', blocks_multiply_const_vxx_1, '0']
- [drm_audio_encoder_sb_0, '0', drm_scrambler_bb_0, '0']
- [drm_generate_fac_b_0, '0', drm_scrambler_bb_0_0, '0']
- [drm_generate_sdc_b_0, '0', drm_scrambler_bb_0_1, '0']
- [drm_interleaver_cc_0, '0', cell_mapping_cc_0, '0']
- [drm_scrambler_bb_0, '0', mlc_bc_0_0_1, '0']
- [drm_scrambler_bb_0_0, '0', mlc_bc_0_0, '0']
- [drm_scrambler_bb_0_1, '0', mlc_bc_0_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_1, '0']
- [mlc_bc_0_0, '0', cell_mapping_cc_0, '2']
- [mlc_bc_0_0_0, '0', cell_mapping_cc_0, '1']
- [mlc_bc_0_0_1, '0', drm_interleaver_cc_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', drm_audio_encoder_sb_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
