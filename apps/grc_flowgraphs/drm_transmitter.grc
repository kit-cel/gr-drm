options:
  parameters:
    author: Felix Wunsch
    category: Custom
    description: Generic DRM Transmitter. For the MSC, only SM and EEP is implemented.
    generate_options: no_gui
    id: drm_transmitter
    output_language: python
    run_options: run
    title: DRM Transmitter
  states: {}

blocks:
- name: tp
  id: variable_drm_config
  parameters:
    RM: '1'
    SO: '3'
    audio_sample_rate: '12000'
    comment: |-
      Before generating the flow graph, define the path 
      to a 24 kHz wav-file and change the parameters 
      of the UHD sink. Do not forget to set the correct 
      audio_sample_rate.
    long_interl: 'True'
    msc_mapping: '2'
    msc_prot_level_2_16: '1'
    msc_prot_level_2_64: '0'
    sdc_mapping: '0'
    station_label: '"GNU Radio on DRM"'
    text_message: '"This is a DRM transmission with GNU Radio"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '7000'
    offset: '0'
    phase: '0'
    samp_rate: drm.FS_SOUNDCARD
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Prevent clipping
    const: '7e-3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: drm_A5.wav
    samp_rate: drm.FS_SOUNDCARD
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/wunsch/Music/new_world_12khz.wav
    repeat: 'False'
  states: {}
- name: cell_mapping_cc_0
  id: cell_mapping_cc
  parameters:
    comment: |-
      Multiplex the three logical
      channels and the pilot cells 
      and create transmission frames.
    tp: tp
  states: {}
- name: digital_ofdm_cyclic_prefixer_1
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: tp.ofdm().nfft()*tp.ofdm().cp_ratio_enum()//tp.ofdm().cp_ratio_denom()
    input_size: tp.ofdm().nfft()
    tagname: ''
  states: {}
- name: drm_audio_encoder_sb_0
  id: drm_audio_encoder_sb
  parameters:
    len_out: tp.msc().L_MUX()
    tp: tp
  states: {}
- name: drm_generate_fac_b_0
  id: drm_generate_fac_b
  parameters:
    tp: tp
  states: {}
- name: drm_generate_sdc_b_0
  id: drm_generate_sdc_b
  parameters:
    tp: tp
  states: {}
- name: drm_interleaver_cc_0
  id: drm_interleaver_cc
  parameters:
    comment: Additional interleaving
    depth: drm.INTL_DEPTH_DRM
    interl_seq: tp.msc().cell_interl_seq()
    long_interl: tp.cfg().long_interl()
  states: {}
- name: drm_scrambler_bb_0
  id: drm_scrambler_bb
  parameters:
    block_len: tp.msc().L_MUX()
  states: {}
- name: drm_scrambler_bb_0_0
  id: drm_scrambler_bb
  parameters:
    block_len: tp.fac().L()
  states: {}
- name: drm_scrambler_bb_0_1
  id: drm_scrambler_bb
  parameters:
    block_len: tp.sdc().L()
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: tp.ofdm().nfft()
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: mlc_bc_0
  id: mlc_bc
  parameters:
    channel_type: '"FAC"'
    comment: |-
      Apply channel coding
      and interleaving
    tp: tp
  states: {}
- name: mlc_bc_0_0
  id: mlc_bc
  parameters:
    channel_type: '"MSC"'
    tp: tp
  states: {}
- name: mlc_bc_0_1
  id: mlc_bc
  parameters:
    channel_type: '"SDC"'
    tp: tp
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Ingoing sample rate is 
      assumed to be 48 kHz.
      250 kHz is one of the
      lowest achievable rates
      of the USRP.
    decim: drm.FS_SOUNDCARD // 1000
    interp: '250'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '240'
    taps: ''
    type: fff
  states: {state: disabled}
- name: sym_in
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: sym_out
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TXA
    center_freq0: 5e6
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: 48000 * 250 / 48
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', drm_audio_encoder_sb_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [cell_mapping_cc_0, '0', sym_out, '0']
- [digital_ofdm_cyclic_prefixer_1, '0', blocks_multiply_const_vxx_1, '0']
- [drm_audio_encoder_sb_0, '0', drm_scrambler_bb_0, '0']
- [drm_generate_fac_b_0, '0', drm_scrambler_bb_0_0, '0']
- [drm_generate_sdc_b_0, '0', drm_scrambler_bb_0_1, '0']
- [drm_interleaver_cc_0, '0', cell_mapping_cc_0, '0']
- [drm_scrambler_bb_0, '0', mlc_bc_0_0, '0']
- [drm_scrambler_bb_0_0, '0', mlc_bc_0, '0']
- [drm_scrambler_bb_0_1, '0', mlc_bc_0_1, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_1, '0']
- [mlc_bc_0, '0', cell_mapping_cc_0, '2']
- [mlc_bc_0_0, '0', drm_interleaver_cc_0, '0']
- [mlc_bc_0_1, '0', cell_mapping_cc_0, '1']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', drm_audio_encoder_sb_0, '0']
- [sym_in, '0', fft_vxx_0, '0']

metadata:
  file_format: 1
