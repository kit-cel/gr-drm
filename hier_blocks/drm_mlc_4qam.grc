<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>drm_mlc_4qam_vbvc</value></param>
<param><key>title</key><value>MLC 4QAM</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>MLC 4QAM</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>DRM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>values given to parameters are only placeholders and are overwritten by the actual configuration in the flow graph</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>vlen_in</value></param>
</block>
<block>
<key>drm_add_tailbits_vbvb</key>
<param><key>id</key><value>add_tailbits_vbvb_0</value></param>
<param><key>vlen_in</key><value>vlen_in</value></param>
<param><key>n_tailbits</key><value>n_tailbits</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>vlen_in + n_tailbits</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(vlen_in + n_tailbits) * denom_mother_code_rate</value></param>
</block>
<block>
<key>drm_punct_vbvb</key>
<param><key>id</key><value>drm_punct_vbvb_0</value></param>
<param><key>punct_pat_1</key><value>pp</value></param>
<param><key>punct_pat_2</key><value>pp_tail</value></param>
<param><key>vlen_in</key><value>(vlen_in + n_tailbits) * denom_mother_code_rate</value></param>
<param><key>vlen_out</key><value>vlen_out * 2</value></param>
<param><key>num_tailbits</key><value>n_tailbits * denom_mother_code_rate</value></param>
</block>
<block>
<key>drm_interleaver_vbvb</key>
<param><key>id</key><value>drm_interleaver_vbvb_0</value></param>
<param><key>interl_seq</key><value>(interl_seq)</value></param>
</block>
<block>
<key>drm_qam_map_vbvc</key>
<param><key>id</key><value>drm_qam_map_vbvc_0</value></param>
<param><key>map_table</key><value>map_tab</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symbol</value></param>
<param><key>vlen_out</key><value>vlen_out</value></param>
<param><key>n_inputs</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen_out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vlen_in</value></param>
<param><key>label</key><value>Input Vector Length</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vlen_out</value></param>
<param><key>label</key><value>Output Vector Length</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_tailbits</value></param>
<param><key>label</key><value>Number of Tail Bits</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>denom_mother_code_rate</value></param>
<param><key>label</key><value>Denominator Mother Code Rate</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>map_tab</value></param>
<param><key>label</key><value>Mapping Table</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interl_seq</value></param>
<param><key>label</key><value>Interleaving Sequence</value></param>
<param><key>value</key><value>(0,1)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_symbol</value></param>
<param><key>label</key><value>Bits per Symbol</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp</value></param>
<param><key>label</key><value>Puncturing Pattern</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_tail</value></param>
<param><key>label</key><value>Puncturing Pattern Tail  Bits</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>denom_mother_code_rate</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_0</value></param>
<param><key>type</key><value>bb</value></param>
<param><key>fsm_args</key><value>1, denom_mother_code_rate, gen_poly</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gen_poly</value></param>
<param><key>label</key><value>Generator Polynomial</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>add_tailbits_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_qam_map_vbvc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vbvb_0</source_block_id><sink_block_id>drm_qam_map_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_punct_vbvb_0</source_block_id><sink_block_id>drm_interleaver_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>drm_punct_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>trellis_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add_tailbits_vbvb_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
