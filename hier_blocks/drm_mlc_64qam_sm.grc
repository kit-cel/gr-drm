<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>drm_mlc_64qam_sm_vbvc</value></param>
<param><key>title</key><value>MLC 64QAM SM</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>MLC 64QAM SM</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>DRM</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_0</value></param>
<param><key>label</key><value>pp_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gen_poly</value></param>
<param><key>label</key><value>gen_poly</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_symbol</value></param>
<param><key>label</key><value>bits_per_symbol</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M_total</value></param>
<param><key>label</key><value>M_total</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_0_tail</value></param>
<param><key>label</key><value>pp_0_tail</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>map_tab</value></param>
<param><key>label</key><value>map_tab</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>denom_mother_code_rate</value></param>
<param><key>label</key><value>denom_mother_code_rate</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_tailbits</value></param>
<param><key>label</key><value>n_tailbits</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vlen_out</value></param>
<param><key>label</key><value>vlen_out</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vlen_in</value></param>
<param><key>label</key><value>vlen_in</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>vlen_in</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>part_len_mid</value></param>
<param><key>label</key><value>part_len_mid</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>part_len_top</value></param>
<param><key>label</key><value>part_len_top</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>part_len_bot</value></param>
<param><key>label</key><value>part_len_bot</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>drm_add_tailbits_vbvb</key>
<param><key>id</key><value>drm_add_tailbits_vbvb_top_0</value></param>
<param><key>vlen_in</key><value>part_len_mid</value></param>
<param><key>n_tailbits</key><value>n_tailbits</value></param>
</block>
<block>
<key>drm_add_tailbits_vbvb</key>
<param><key>id</key><value>drm_add_tailbits_vbvb_top</value></param>
<param><key>vlen_in</key><value>part_len_top</value></param>
<param><key>n_tailbits</key><value>n_tailbits</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_top_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>part_len_mid + n_tailbits</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_top</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>part_len_top + n_tailbits</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_top</value></param>
<param><key>type</key><value>bb</value></param>
<param><key>fsm_args</key><value>1, denom_mother_code_rate, gen_poly</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_top</value></param>
<param><key>k</key><value>denom_mother_code_rate</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_top</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(part_len_top + n_tailbits) * denom_mother_code_rate</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_top_0</value></param>
<param><key>type</key><value>bb</value></param>
<param><key>fsm_args</key><value>1, denom_mother_code_rate, gen_poly</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_mid</value></param>
<param><key>k</key><value>denom_mother_code_rate</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_mid</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(part_len_bot + n_tailbits) * denom_mother_code_rate</value></param>
</block>
<block>
<key>drm_punct_vbvb</key>
<param><key>id</key><value>drm_punct_vbvb_top</value></param>
<param><key>punct_pat_1</key><value>pp_0</value></param>
<param><key>punct_pat_2</key><value>pp_0_tail</value></param>
<param><key>vlen_in</key><value>(part_len_top + n_tailbits) * denom_mother_code_rate</value></param>
<param><key>vlen_out</key><value>vlen_out * 2</value></param>
<param><key>num_tailbits</key><value>n_tailbits * denom_mother_code_rate</value></param>
</block>
<block>
<key>drm_punct_vbvb</key>
<param><key>id</key><value>drm_punct_vbvb_mid</value></param>
<param><key>punct_pat_1</key><value>pp_1</value></param>
<param><key>punct_pat_2</key><value>pp_1_tail</value></param>
<param><key>vlen_in</key><value>(part_len_mid+ n_tailbits) * denom_mother_code_rate</value></param>
<param><key>vlen_out</key><value>vlen_out * 2</value></param>
<param><key>num_tailbits</key><value>n_tailbits * denom_mother_code_rate</value></param>
</block>
<block>
<key>drm_punct_vbvb</key>
<param><key>id</key><value>drm_punct_vbvb_bot</value></param>
<param><key>punct_pat_1</key><value>pp_2</value></param>
<param><key>punct_pat_2</key><value>pp_2_tail</value></param>
<param><key>vlen_in</key><value>(part_len_bot + n_tailbits) * denom_mother_code_rate</value></param>
<param><key>vlen_out</key><value>vlen_out * 2</value></param>
<param><key>num_tailbits</key><value>n_tailbits * denom_mother_code_rate</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_bot</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(part_len_bot + n_tailbits) * denom_mother_code_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_1</value></param>
<param><key>label</key><value>pp_1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_1_tail</value></param>
<param><key>label</key><value>pp_1_tail</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_2</value></param>
<param><key>label</key><value>pp_2</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pp_2_tail</value></param>
<param><key>label</key><value>pp_2_tail</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interl_seq_1_2</value></param>
<param><key>label</key><value>interl_seq_1_2</value></param>
<param><key>value</key><value>(0,1)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interl_seq_2_2</value></param>
<param><key>label</key><value>interl_seq_2_2</value></param>
<param><key>value</key><value>(0,1)</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_bot</value></param>
<param><key>k</key><value>denom_mother_code_rate</value></param>
</block>
<block>
<key>drm_partitioning_64sm_vbvb</key>
<param><key>id</key><value>drm_partitioning_64sm_vbvb_0</value></param>
<param><key>vlen_in</key><value>vlen_in</value></param>
<param><key>vlen_out</key><value>M_total</value></param>
<param><key>vlen1</key><value>part_len_top</value></param>
<param><key>vlen2</key><value>part_len_mid</value></param>
<param><key>vlen3</key><value>part_len_bot</value></param>
</block>
<block>
<key>drm_qam_map_vbvc</key>
<param><key>id</key><value>drm_qam_map_vbvc_0</value></param>
<param><key>map_table</key><value>map_tab</value></param>
<param><key>bits_per_symbol</key><value>bits_per_symbol</value></param>
<param><key>vlen_out</key><value>vlen_out</value></param>
<param><key>n_inputs</key><value>3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen_out</value></param>
</block>
<block>
<key>drm_interleaver_vbvb</key>
<param><key>id</key><value>drm_interleaver_vbvb_mid</value></param>
<param><key>interl_seq</key><value>(interl_seq_1_2)</value></param>
</block>
<block>
<key>drm_interleaver_vbvb</key>
<param><key>id</key><value>drm_interleaver_vbvb_bot</value></param>
<param><key>interl_seq</key><value>(interl_seq_2_2)</value></param>
</block>
<block>
<key>drm_interleaver_vbvb</key>
<param><key>id</key><value>drm_interleaver_vbvb_top</value></param>
<param><key>interl_seq</key><value>(interl_seq_0_2)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interl_seq_0_2</value></param>
<param><key>label</key><value>interl_seq_0_2</value></param>
<param><key>value</key><value>(0,1)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_bot</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>part_len_bot + n_tailbits</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_bot</value></param>
<param><key>type</key><value>bb</value></param>
<param><key>fsm_args</key><value>1, denom_mother_code_rate, gen_poly</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>drm_add_tailbits_vbvb</key>
<param><key>id</key><value>drm_add_tailbits_vbvb_bot</value></param>
<param><key>vlen_in</key><value>part_len_bot</value></param>
<param><key>n_tailbits</key><value>n_tailbits</value></param>
</block>
<connection><source_block_id>blocks_unpack_k_bits_bb_top</source_block_id><sink_block_id>blocks_stream_to_vector_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_top</source_block_id><sink_block_id>drm_punct_vbvb_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_punct_vbvb_top</source_block_id><sink_block_id>drm_interleaver_vbvb_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vbvb_top</source_block_id><sink_block_id>drm_qam_map_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_qam_map_vbvc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_partitioning_64sm_vbvb_0</source_block_id><sink_block_id>drm_add_tailbits_vbvb_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_partitioning_64sm_vbvb_0</source_block_id><sink_block_id>drm_add_tailbits_vbvb_bot</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>drm_partitioning_64sm_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_add_tailbits_vbvb_top</source_block_id><sink_block_id>blocks_vector_to_stream_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_top</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_top</source_block_id><sink_block_id>trellis_encoder_xx_top</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_add_tailbits_vbvb_top_0</source_block_id><sink_block_id>blocks_vector_to_stream_top_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_top_0</source_block_id><sink_block_id>trellis_encoder_xx_top_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_partitioning_64sm_vbvb_0</source_block_id><sink_block_id>drm_add_tailbits_vbvb_top_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_bot</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_bot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vbvb_bot</source_block_id><sink_block_id>drm_qam_map_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>drm_punct_vbvb_bot</source_block_id><sink_block_id>drm_interleaver_vbvb_bot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_bot</source_block_id><sink_block_id>drm_punct_vbvb_bot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_bot</source_block_id><sink_block_id>blocks_stream_to_vector_bot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_punct_vbvb_mid</source_block_id><sink_block_id>drm_interleaver_vbvb_mid</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_mid</source_block_id><sink_block_id>drm_punct_vbvb_mid</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_mid</source_block_id><sink_block_id>blocks_stream_to_vector_mid</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vbvb_mid</source_block_id><sink_block_id>drm_qam_map_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_top_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_mid</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_add_tailbits_vbvb_bot</source_block_id><sink_block_id>blocks_vector_to_stream_bot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_bot</source_block_id><sink_block_id>trellis_encoder_xx_bot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
